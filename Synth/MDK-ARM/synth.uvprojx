# Keil uVision project synth.uvprojx, settings and files
target AudioDemoTwo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: synth
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2s.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c.c stm32f4xx_ll_usb.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c
  group Audio/Drivers
    ../Drivers/Audio/: cs43l22.c stm32f4_discovery.c stm32f4_discovery_audio.c audio.h cs43l22.h pdm2pcm_glo.h stm32f4_discovery.h stm32f4_discovery_audio.h
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c Oscillator.c Buttons.c Oscillator.h OutputMixer.c OutputMixer.h main.h Envelope.h Operator.c Operator.h Control.c Control.h Envelope.c noteTable.c noteTable.h Synth.c Synth.h LED.c LED.h MIDI.c MIDI.h config.h VoxManager.c AlgManager.c VoxManager.h AlgManager.h Presets.c Presets.h
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.1.2
